## hw/polarissimu/Kconfig
```kconfig
config POLARIS_WIRELESS
    bool
    default y if PCI_DEVICES
    depends on PCI
```
